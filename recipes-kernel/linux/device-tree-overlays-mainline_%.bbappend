FILESEXTRAPATHS:prepend := "${THISDIR}/${PN}:"

SRC_URI += "file://0001-Update-36S-overlays.patch;patchdir=.. file://0002-Add-36S-overlays.patch;patchdir=.."

