require ${BPN}.inc

SRC_URI[sha256sum] = "b7eac8c79244806b1c276eeeacc329e4a5b31a370804c4b0c7cd16837783f78b"
